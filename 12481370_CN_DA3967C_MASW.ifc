Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-03-18T08:17:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 18 08:17:32 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\2424abfd-4859-4e72-9304-bfa5b83a34b1\8af6dd5a-50b3-40bc-b3d8-147517b7806d\ifc * Database version: 5507 * Database creation date: Mon Mar 18 08:17:32 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 18 08:17:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 18 08:17:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12481370_CN_DA3967C_MASW:28W3967M_CN_12481370_DA3967C_MASW, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 28W3967M_CN_12481370_DA3967C_MASW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28W3967M_CN_12481370_DA3967C_MASW
Material: z_Miele_Design_CLST, z_Miele_Design_Glass, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, mate black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
